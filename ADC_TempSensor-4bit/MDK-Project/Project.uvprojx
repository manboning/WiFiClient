# Keil uVision project Project.uvprojx, settings and files
target PY32F030_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F030x6 Puya
  pack: Puya.PY32F0xx_DFP.1.1.7
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x6
  c include: ..\User;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\PY32F0xx_HAL_Driver\Inc;..\DOC;..\Drivers\CMSIS\Device\PY32F0xx\Source\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Common
    ../User/: system_py32f0xx.c
    ../Drivers/CMSIS/Device/PY32F0xx/Source/arm/: startup_py32f030xx.s
  group User
    ../User/: main.c py32f0xx_it.c py32f0xx_hal_msp.c font_assets.c icons.c lcd.c gfx_driver.c ui_layout.c display_refresh.c
    ../User/usart/: bsp_usart.c
  group PY32F0xx_HAL_Driver
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c
  group Doc
    ../DOC/: readme.txt
software components: CMSIS:CORE 5.1.2
